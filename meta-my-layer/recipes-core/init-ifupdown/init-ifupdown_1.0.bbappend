SRC_URI += "file://0001-Personal-Static-IP.patch"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

