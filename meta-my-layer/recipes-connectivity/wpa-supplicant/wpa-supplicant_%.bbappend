FILESEXTRAPATHS:prepend:poky := "${THISDIR}/wpa-supplicant:"
SRC_URI += "file://wpa_supplicant.conf-sane"
